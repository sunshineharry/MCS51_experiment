# Keil uVision project code_3.uvproj, settings and files
target code_3 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code_3 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: ADC0808.c main.c
  group dependence
    ./dependence/: ADC0808.H DAC0832.H
