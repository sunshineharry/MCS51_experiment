# Keil uVision project code_1.uvproj, settings and files
target code_1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\dependence;.\src
  group src
    ./src/: 8051.h main.c
